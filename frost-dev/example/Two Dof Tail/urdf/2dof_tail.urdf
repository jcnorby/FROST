Commit message: Initial commit for 2dof tail testing

File: frost-dev/example/Two Dof Tail/urdf/2dof_tail.urdf (robot description, URDF)
Before this commit: robot two_dof_tail, 3 links, 2 joints
Links:
- link tail_link_1: mass 0.0693 -> 0.000001
- link tail_link_2: mass 0.0693 -> 1.0
